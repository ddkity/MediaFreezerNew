# Keil uVision project demo@mkl16z.uvproj, settings and files
target demo@mkl16z (ARM-ADS)
  device: MKL26Z128xxx4 Freescale
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: demo@mkl16z
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: ..\..\..\..\img_pkg\img_pkg_win.exe -i .\output@mkl16z\demo@mkl16z.bin\ER_IROM1 -o demo@mkl16z.img -t mkl16z
  c flags: Optim=1 uC99=1 wLevel=2
  c define: MCU_NXP_KINETIS_CM0P KEIL FREEDOM CMSIS AYLA_KEIL __NO_EMBEDDED_ASM DEMO_IMG_MGMT AYLA_HOST_OTA DEMO_SCHED_LIB DEMO_TIME_LIB AYLA_SCHED AYLA_TIME DEMO_CONF AYLA_CONF DEMO_FILE_PROP AYLA_FILE_PROP SOFT_CRC
  c include: ..\..\..\arch;..\..\..\lib\ayla\include;..\..\..\lib\ayla\include\ayla;..\..\..\lib\ayla\config\include;..\..\..\lib\ayla\file_prop\include;..\..\..\lib\ayla\host_ota\include;..\..\..\lib\ayla\sched\include;..\..\..\lib\ayla\spi\include;..\..\..\lib\ayla\uart\include;..\..\..\example\file_prop;..\..\..\example\ledevb;..\..\..\..\KSDK\common;..\..\..\..\KSDK\platforms;..\..\..\..\KSDK\cpu;..\..\..\..\KSDK\cpu\headers\CMSIS\MKL26Z4\Include;..\..\..\..\KSDK\drivers\ftfa;..\..\..\..\KSDK\drivers\gpio;..\..\..\..\KSDK\drivers\mcg;..\..\..\..\KSDK\drivers\rcm;..\..\..\..\KSDK\drivers\spi;..\..\..\..\KSDK\drivers\uart;..\..\..\..\common;..\..\..\..\..\SEGGER_RTT\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x1800 size 0x1e800
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group demo
    ../../../example/ledevb/: demo.c
    ../../../example/file_prop/: demo_stream.c
    ../../../example/img_mgmt/: demo_img_mgmt.c
    ../../../example/wifi_mgmt/: wifi_demo.c
  group Ayla
    ../../../lib/ayla/: byte_order.c crc16.c props.c serial_msg.c tlv.c utf8.c
  group arch
    ../../../arch/: mcu_io.c spi_platform.c uart_platform.c stm32.c
  group Ayla_config
    ../../../lib/ayla/config/: conf_access.c
  group Ayla_host_ota
    ../../../lib/ayla/host_ota/: host_ota.c
  group Ayla_sched
    ../../../lib/ayla/sched/: clock_utils.c sched.c schedeval.c
  group Ayla_file_prop
    ../../../lib/ayla/file_prop/: prop_dp.c
  group Ayla_spi
    ../../../lib/ayla/spi/: spi.c spi_ping.c
  group Ayla_uart
    ../../../lib/ayla/uart/: uart.c
  group cpu
    ../../../../KSDK/cpu/: start_demo.c sysinit_demo.c
    ../../../../KSDK/cpu/CMSIS/Source/: system_MKL16Z4.c startup_MKL16Z4.s
  group drivers
    ../../../../KSDK/drivers/gpio/: gpio.c
    ../../../../KSDK/drivers/rcm/: rcm.c
    ../../../../KSDK/drivers/spi/: spi.c
    ../../../../KSDK/drivers/uart/: Retarget.c Serial.c uart.c
    ../../../../KSDK/drivers/ftfa/: ftfl_flash.c flash_app.c
  group crc
    ../../../../common/: QuickCRC8.c
  group RTT
    ../../../../../SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../SEGGER_RTT/Syscalls/: SEGGER_RTT_Syscalls_KEIL.c
