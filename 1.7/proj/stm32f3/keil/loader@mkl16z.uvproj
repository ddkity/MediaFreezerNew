# Keil uVision project loader@mkl16z.uvproj, settings and files
target loader@mkl16z (ARM-ADS)
  device: MKL16Z128xxx4 Freescale
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: loader@mkl16z
  c flags: Optim=1
  c define: MCU_NXP_KINETIS_CM0P FREEDOM CMSIS KEIL AYLA_KEIL
  c include: ..\..\..\lib\ayla\include;..\..\..\arch;..\..\..\..\KSDK\common;..\..\..\..\KSDK\platforms;..\..\..\..\KSDK\cpu;..\..\..\..\KSDK\cpu\headers\CMSIS\MKL26Z4\Include;..\..\..\..\KSDK\drivers\ftfa;..\..\..\..\KSDK\drivers\mcg;..\..\..\..\KSDK\drivers\rcm;..\..\..\..\KSDK\drivers\uart
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400
  memory RVCT5: ROM 0x800 size 0x1000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group loader
    ../../../arch/: loader.c
  group cpu
    ../../../../KSDK/cpu/: start_loader.c sysinit_loader.c
    ../../../../KSDK/cpu/CMSIS/Source/: startup_MKL16Z4.s system_MKL16Z4.c
  group drivers
    ../../../../KSDK/drivers/ftfa/: flash_app.c ftfl_flash.c
  group keil
    ./: bb_entry.s
