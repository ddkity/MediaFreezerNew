# Keil uVision project demo@stm32f0.uvprojx, settings and files
target demo@stm32f0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030CC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: demo@stm32f0 +hex
  AfterMake: fromelf --bin --output=demo@stm32f0.bin output@stm32f0\demo@stm32f0.axf
  AfterMake: ..\..\..\..\img_pkg\img_pkg_win.exe -i demo@stm32f0.bin -o demo@stm32f0.img -t stm32f0
  c flags: Optim=1 uC99=1 wLevel=2
  c define: MCU_ST_STM32_CM0 STM32F030xC USE_STDPERIPH_DRIVER AYLA_KEIL __NO_EMBEDDED_ASM DEMO_IMG_MGMT AYLA_HOST_OTA DEMO_SCHED_LIB DEMO_TIME_LIB AYLA_SCHED AYLA_TIME DEMO_CONF AYLA_CONF DEMO_FILE_PROP AYLA_FILE_PROP AYLA_WIFI_DEMO AYLA_WIFI_JOIN SOFT_CRC
  c include: ..\..\..\..\STM32F0xx_StdPeriph_Driver\inc;..\..\..\lib\ayla\include;..\..\..\arch;..\..\..\lib\ayla\config\include;..\..\..\lib\ayla\file_prop\include;..\..\..\lib\ayla\host_ota\include;..\..\..\lib\ayla\sched\include;..\..\..\lib\ayla\spi\include;..\..\..\example\file_prop;..\..\..\example\ledevb;..\..\..\lib\ayla\uart\include;..\..\..\..\common;..\..\..\..\..\SEGGER_RTT\RTT;.\
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x3e000
  memory RVCT9: RAM 0x200000c0 size 0x8000
  group demo
    ../../../example/ledevb/: demo.c rfsmarthandle.c
    ../../../example/file_prop/: demo_stream.c
    ../../../example/img_mgmt/: demo_img_mgmt.c
    ../../../example/wifi_mgmt/: wifi_demo.c
  group Ayla
    ../../../lib/ayla/: byte_order.c crc16.c props.c serial_msg.c tlv.c utf8.c
  group ST
    ../../../..//STM32F0xx_StdPeriph_Driver/src/: system_stm32f0xx.c
    ../../../../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_usart.c startup_stm32f030xc.s stm32f0xx_misc.c stm32f0xx_tim.c
  group arch
    ../../../arch/: mcu_io.c spi_platform.c stm32.c uart_platform.c
  group Ayla_config
    ../../../lib/ayla/config/: conf_access.c
  group Ayla_host_ota
    ../../../lib/ayla/host_ota/: host_ota.c
  group Ayla_sched
    ../../../lib/ayla/sched/: clock_utils.c sched.c schedeval.c
  group Ayla_file_prop
    ../../../lib/ayla/file_prop/: prop_dp.c
  group Ayla_spi
    ../../../lib/ayla/spi/: spi.c spi_ping.c
  group Ayla_uart
    ../../../lib/ayla/uart/: uart.c
  group crc
    ../../../../common/: QuickCRC8.c
software components: CMSIS:CORE 5.0.1
