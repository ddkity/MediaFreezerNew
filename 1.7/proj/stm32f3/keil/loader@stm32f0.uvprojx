# Keil uVision project loader@stm32f0.uvprojx, settings and files
target loader@stm32f0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030CC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: loader@stm32f0 +hex
  c flags: Optim=1
  c define: MCU_ST_STM32_CM0 STM32F030xC USE_STDPERIPH_DRIVER AYLA_KEIL
  c include: ..\..\..\lib\ayla\include;..\..\..\arch;..\..\..\..\STM32F0xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group loader
    ../../../arch/: loader.c
  group ST
    ../../../../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_flash.c startup_stm32f030xc.s system_stm32f0xx.c
  group keil
    ./: bb_entry.s
software components: CMSIS:CORE 5.0.1
