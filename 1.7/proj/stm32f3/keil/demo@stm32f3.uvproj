# Keil uVision project demo@stm32f3.uvproj, settings and files
target demo@stm32f3 (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: demo@stm32f3
  AfterMake: fromelf --bin --output=demo@stm32f3.bin output@stm32f3\demo@stm32f3.axf
  AfterMake: ..\..\..\..\img_pkg\img_pkg_win.exe -i demo@stm32f3.bin -o demo@stm32f3.img -t stm32f3
  c flags: Optim=1 uC99=1 wLevel=2
  c define: RTT MCU_ST_STM32_CM4 STM32F30X USE_STDPERIPH_DRIVER AYLA_KEIL __NO_EMBEDDED_ASM DEMO_IMG_MGMT AYLA_HOST_OTA DEMO_SCHED_LIB DEMO_TIME_LIB AYLA_SCHED AYLA_TIME DEMO_CONF AYLA_CONF DEMO_FILE_PROP AYLA_FILE_PROP
  c include: ..\..\..\..\STM32F30x_StdPeriph_Driver\inc;..\..\..\lib\ayla\include;..\..\..\arch;..\..\..\lib\ayla\config\include;..\..\..\lib\ayla\file_prop\include;..\..\..\lib\ayla\host_ota\include;..\..\..\lib\ayla\sched\include;..\..\..\lib\ayla\spi\include;..\..\..\example\file_prop;..\..\..\example\ledevb;..\..\..\lib\ayla\uart\include;..\..\..\..\common;..\..\..\..\..\SEGGER_RTT\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x3c000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group demo
    ../../../example/ledevb/: demo.c
    ../../../example/file_prop/: demo_stream.c
    ../../../example/img_mgmt/: demo_img_mgmt.c
    ../../../example/wifi_mgmt/: wifi_demo.c
  group Ayla
    ../../../lib/ayla/: byte_order.c crc16.c props.c serial_msg.c tlv.c utf8.c
  group ST
    C:/Keil/ARM/Startup/ST/STM32F30x/: system_stm32f30x.c startup_stm32f30x.s
    ../../../../STM32F30x_StdPeriph_Driver/src/: stm32f30x_exti.c stm32f30x_gpio.c stm32f30x_rcc.c stm32f30x_misc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_flash.c
    ../../../arch/: stm32f3_discovery.c
  group arch
    ../../../arch/: mcu_io.c spi_platform.c stm32.c uart_platform.c
  group Ayla_config
    ../../../lib/ayla/config/: conf_access.c
  group Ayla_host_ota
    ../../../lib/ayla/host_ota/: host_ota.c
  group Ayla_sched
    ../../../lib/ayla/sched/: clock_utils.c sched.c schedeval.c
  group Ayla_file_prop
    ../../../lib/ayla/file_prop/: prop_dp.c
  group Ayla_spi
    ../../../lib/ayla/spi/: spi.c spi_ping.c
  group Ayla_uart
    ../../../lib/ayla/uart/: uart.c
  group crc
    ./../../../../common/: QuickCRC8.c
  group RTT
    ../../../../../SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../SEGGER_RTT/Syscalls/: SEGGER_RTT_Syscalls_KEIL.c
