# Keil uVision project loader@stm32f3.uvproj, settings and files
target loader@stm32f3 (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: loader@stm32f3
  c flags: Optim=1
  c define: MCU_ST_STM32_CM4 STM32F30X USE_STDPERIPH_DRIVER AYLA_KEIL
  c include: ..\..\..\lib\ayla\include;..\..\..\arch;..\..\..\..\STM32F30x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group loader
    ../../../arch/: loader.c
  group ST
    C:/Keil/ARM/Startup/ST/STM32F30x/: system_stm32f30x.c startup_stm32f30x.s
    ../../../../STM32F30x_StdPeriph_Driver/src/: stm32f30x_flash.c
  group keil
    ./: bb_entry.s
